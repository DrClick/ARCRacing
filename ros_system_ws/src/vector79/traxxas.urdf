Commit message: updated traxxas model, created playback launch

File: ros_system_ws/src/vector79/traxxas.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://vector79/traxxas.dae
